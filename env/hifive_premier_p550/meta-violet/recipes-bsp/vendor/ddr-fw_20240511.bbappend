SRC_URI = "git://github.com/sifiveinc/hifive-premier-p550-tools.git;branch=${BRANCH};protocol=https"
