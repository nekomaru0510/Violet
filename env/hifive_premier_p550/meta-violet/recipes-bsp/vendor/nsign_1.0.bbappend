SRC_URI = "git://github.com/eswincomputing/Esbd-77serial-nsign.git;branch=${BRANCH};protocol=https \
           file://0001-Changes-in-CMakeLists.txt.patch"
